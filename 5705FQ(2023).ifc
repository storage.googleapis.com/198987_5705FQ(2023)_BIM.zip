Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-29T00:13:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 29 00:13:46 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8f60cd24-d351-4d47-92a9-e92f049f2c17\03622a71-7f03-4d27-a8f1-ab361f260cdf\ifc * Database version: 5507 * Database creation date: Mon Jan 29 00:13:45 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 29 00:13:45 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 29 00:13:45 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 5705FQ Oras Care, 5705FQ(2023):5705FQ Oras Care:99924
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 152.153 mm; FaucetNominalHeight: 177.64 mm; FaucetNominalWidth: 50.1115 mm; HandShowerNominalDepth: 68.5 mm; HandShowerNominalHeight: 316.9 mm; HandShowerNominalWidth: 57 mm; InletConnectionSize: 10 mm
Type - Electrical - Battery: AA 1.5 V Lithium x 2, CR 2450 3 V; Bluetooth: No Bluetooth; Electrical Connection: 9 V; Operating Voltage: 39 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 5705FQ(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 6414150105265; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; EN Standard: EN 15091, ETSI EN 301 489-1 V1.9.2 , ETSI EN 300 328 v2.2.2 , EN 61000-6-1:2007 , EN 61000-6-3:2007+A1:2011+AC:2012 , EN 60335-1:2012+A11+A13+A1+A14+A2+A15:2021, Part 19.11.4; Sales Package dimensions (LxWxH): 590 x 180 x 63; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/5705FQ; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/190197_5705FQ_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL WEEE: http://static.oras.com/WEEE/5705FQ
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/5705FQ; Catalog Drawing URL: http://static.oras.com/catdrw/5705FQ; Dimension Drawing URL: http://static.oras.com/dimdrw/5705FQ; FDV Document URL: http://www.oras.com/datasheet/5705FQ/en/fdv; Group: Sales item; Installation and Maintenance Guide URL: http://static.oras.com/manual/5705FQ; Long Marketing: Hybrid faucet with laminar flow aerator. Easy grip temperature lever for good grip and easy adjustment. SMART intelligent bluetooth sensor with 3 optical lenses for improved performance SMART Remote bidetta option with automated on and off water function. Antiscalding protection for Sensor and Remote bidetta operation Easy installation due to fast and easy 3S installation system.; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/5705FQ; Model: 5705FQ Oras Care; Name_en: 5705FQ Oras Care; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 5705FQ; Product Family: null Single-lever;Hybrid;Battery-operated; Product Image URL: http://static.oras.com/image/5705FQ; Product URL: http://static.oras.com/5705FQ; Short Marketing: Care Hybrid series is giving you a whole new modern design to fit into any bathroom. The lever gives you easy and intuitive operation and with our intelligent touchless functions build into same faucet it also supports hygiene operation without any touch needed. Key Features Newest Sensor technology for better detection and operation comfort Antiscalding protection for Sensor and Bidetta usage Intuitive bidetta Incl. 2xAA battery incl. 30 cm cable; Technical DataSheet URL: http://www.oras.com/datasheet/5705FQ/en; Type Name: 5705FQ Oras Care; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass;3S-installation system for safe and simple mounting; Aerator: Standard aerator; Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection: Flexible inlet pipes; Electronic Parts: ;Power supply;Light indicated function(s); Hand Shower: Bidetta hand shower; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max Flow Period: 2 min (1 - 1800 s); Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Operating Distance: 0-30 mm ( 30/90/110/130 mm); Shower Parts: Hand shower;Shower holder;Shower hose (1750 mm); Spout Type: Fixed spout; Surface treatment: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5705FQ(2023); Features: Washbasin faucet; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 5705FQ; Name: 5705FQ Oras Care; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 50x155x180 mm / Hand shower: 60x70x320 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0882931 m2; Volume: 0.00259347 m3
Identity Data - Mark: 41
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 5705FQ(2023): 5705FQ Oras Care; Family and Type: 5705FQ(2023): 5705FQ Oras Care; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5705FQ(2023): 5705FQ Oras Care; Type Id: 5705FQ(2023): 5705FQ Oras Care; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
